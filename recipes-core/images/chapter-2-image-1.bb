
SUMMARY = "Chapter II part 1"
LICENSE = "MIT"
inherit core-image

inherit extrausers
EXTRA_USERS_PARAMS += 'usermod -p '\$5\$GXWuuigS\$fcRncVPUn5uT1dVYdKCWruHHnuf7z4Jpdjbo9kw6r0A' root;'
EXTRA_USERS_PARAMS += 'useradd -p '\$5\$W1wP3Vlt\$JsLmymCVcThF6Y5aL2rZoxFjDSE7svmPadW7D8XaY77' guest;'

