SRC_URI += "file://fragment.cfg;subdir=busybox-1.35.0"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

